# Keil uVision project Infantry-H7.uvprojx, settings and files
target Infantry-H7 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2401FFFF) IROM(0x08000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Infantry-H7 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;../User/application/module/chassis;../User/application/module/detect;../User/application/module/gimbal;../User/application/module/imu;../User/application/module/mini_gimbal;../User/application/module/referee;../User/application/module/shoot;../User/application/module/tick;../User/application/module/ui;../User/application/task;../User/application/test/feedforward;../User/bsp/dm02;../User/components/algorithm/EKF;../User/components/algorithm/user_lib;../User/components/controller/pid;../User/components/device/BMI088;../User/components/device/control/DT7;../User/components/device/IST8310;../User/components/device/motor/DJI-2006;../User/components/device/motor/DJI-3508;../User/components/device/motor/DJI-6020;../User/components/device/motor/DM-4310;../User/components/device/motor/DM-4310-V41;../User/components/device/supercap;../User/components/device/ws2812;../User/components/support;../User/components/support/crc;../User/components/support/fifo;../User/components/support/vofa+
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x20000
  scatter file: stm32h723xg_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c crc.c dma.c fdcan.c i2c.c memorymap.c octospi.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_ospi.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/ST/ARM/DSP/Lib
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM7lfsp_math.lib
  group User/Application/Module
    ../User/application/module/chassis/: chassis.c chassis_behaviour.c chassis_power_control.c
    ../User/application/module/detect/: detect.c
    ../User/application/module/gimbal/: auto_shoot.c gimbal.c gimbal_behaviour.c
    ../User/application/module/imu/: imu.c
    ../User/application/module/mini_gimbal/: mini_gimbal.c
    ../User/application/module/referee/: referee.c
    ../User/application/module/shoot/: shoot.c
    ../User/application/module/tick/: tick.c
    ../User/application/module/ui/: ui.c ui_data.c
  group User/Application/Task
    ../User/application/task/: auto_shoot_task.c buzzer_task.c chassis_task.c detect_task.c gimbal_task.c imu_task.c led_task.c referee_task.c remote_control_task.c shoot_task.c ui_task.c usb_task.c watch_task.c
  group User/Application/Test
    ../User/application/test/feedforward/: feedforward.c
  group User/Bsp/dm02
    ../User/bsp/dm02/: bsp_adc.c bsp_can.c bsp_crc32.c bsp_gpio.c bsp_pwm.c bsp_tim.c bsp_uart.c
  group User/components/algorithm
    ../User/components/algorithm/EKF/: kalman_filter.c QuaternionEKF.c
    ../User/components/algorithm/user_lib/: user_lib.c
  group User/components/controller
    ../User/components/controller/pid/: pid.c
  group User/components/device
    ../User/components/device/BMI088/: BMI088driver.c BMI088Middleware.c
    ../User/components/device/control/DT7/: dt7.c
    ../User/components/device/IST8310/: ist8310driver.c ist8310driver_middleware.c
    ../User/components/device/motor/DJI-2006/: dji_2006.c
    ../User/components/device/motor/DJI-3508/: dji_3508.c
    ../User/components/device/motor/DJI-6020/: dji_6020.c
    ../User/components/device/motor/DM-4310/: dm_4310.c
    ../User/components/device/motor/DM-4310-V41/: dm_4310_v41.c
    ../User/components/device/supercap/: supercap.c
    ../User/components/device/ws2812/: ws2812.c
  group User/components/support
    ../User/components/support/crc/: CRC8_CRC16.c
    ../User/components/support/fifo/: fifo.c
    ../User/components/support/vofa+/: vofa.c
software components: CMSIS:CORE 4.3.0
